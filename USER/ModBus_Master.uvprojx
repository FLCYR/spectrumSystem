# Keil uVision project ModBus_Master.uvprojx, settings and files
target ModBusProgramm (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BEEP +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\MODBUS_MASTER;..\HARDWARE\TIMER;.\GLTCON;..\EEPROM;..\SPI;..\SPI2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MODBUS_MASTER/: master.c
    ../HARDWARE/TIMER/: timer.c
    ./: iwdg.c crc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ./: shutter.c sht20.c motor.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_spi.c
  group README
    ../: README.TXT
  group gltcon
    ./GLTCON/: glt.c
  group EEPROM
    ../EEPROM/: i2c_ee.c
    ./: new_i2c_ee.c
  group config
    ./: addrMap.h
  group SPI
    ../SPI/: spi.c
    ../SPI2/: spi2.c
  group Fitting
    ./: fitting_algorithm.c
